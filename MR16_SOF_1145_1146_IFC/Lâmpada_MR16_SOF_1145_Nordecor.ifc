Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-03-05T15:18:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 05 15:18:37 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\7c366383-8c49-4682-b019-49a63114bdfb\96de5e8d-3fd3-44f8-afc9-d7c2768f614a\ifc * Database version: 5507 * Database creation date: Wed Mar 05 15:18:35 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 05 15:18:36 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 05 15:18:36 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328338
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 1145, Lâmpada_MR16_SOF_1145_1146_Nordecor_IFC:1145:328338
In: Nível 1
Type - Material: Metal - Ferro, Plástico - Branco - Fosco, Plástico - Acrilico - Translucido, LED
Type - Cotas - Altura: 53 mm; Diâmetro: 50 mm
Type - Dados - Data de atualização: 24/02/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Lâmpada de LED MR16 SOF 7W 2700K 40º Dimerizável 127V; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú-SC / Brasil; Modelo: 1145; Nome do tipo: 1145; Número OmniClass: 23.80.70.00; Observação: Soquete GU 10; Tipo de imagem: Imagem raster: MR16.jpg; Título OmniClass: Lighting; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/lampada-led-mr16-dimerizavel-7w-2-700k-irc95/; Vida útil: 25.000h
Type - Elétrico - Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Lâmpada: 0 W
Type - Engenharia elétrica - Corrente elétrica: 0.04 A; Fator de potência - Lâmpada: 0.4; Voltagem - Lâmpada: 127 V
Type - Estrutural - Peso: 0.022Kg
Type - Fotométricos - Ângulo de abertura: 40 deg; Fluxo luminoso: 525 lm; Potência: 7 W; Temperatura de cor: 2700 K
Type - Gráficos - Simbologia: Imagem raster: 1145_1146.png
Type - Materiais e acabamentos - MR11: Alumínio e polímero sintético
Type - Outros - Categoria: Luminárias; 2700K - 36º: yes; Branco: yes; Nome da família: Lâmpada_MR16_SOF_1145_1146_Nordecor_IFC
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes; F. Luminosa: yes
Cotas - Área: 0.00692764 m2; Volume: 0.0000603606 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 127 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Lâmpada_MR16_SOF_1145_1146_Nordecor_IFC: 1145; Família e tipo: Lâmpada_MR16_SOF_1145_1146_Nordecor_IFC: 1145; ID de tipo: Lâmpada_MR16_SOF_1145_1146_Nordecor_IFC: 1145; Tipo: Lâmpada_MR16_SOF_1145_1146_Nordecor_IFC: 1145
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
